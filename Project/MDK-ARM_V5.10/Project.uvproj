# Keil uVision project Project.uvproj, settings and files
target UCORTEX (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: TEST +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\FWLib_3_5_0\CMSIS\CM3\CoreSupport;..\..\FWLib_3_5_0\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\FWLib_3_5_0\STM32F10x_StdPeriph_Driver\inc;..\..\Project;..\..\Drives\LED;..\..\Drives\KEY;..\..\Common\DELAY;..\..\Drives\USART;..\..\Common;..\..\Drives\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group PROJECT
    ../: main.c stm32f10x_it.c system_stm32f10x.c
  group DRIVERS
    ../../Drives/LED/: led.c
    ../../Drives/KEY/: key.c
    ../../Drives/USART/: usart.c
    ../../Drives/OLED/: oled.c
  group COMMON
    ../../Common/DELAY/: delay.c
  group FWLib_3_5_0
    ../../FWLib_3_5_0/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c
  group CMSIS
    ../../FWLib_3_5_0/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../FWLib_3_5_0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group DOC
    ../../: 例程说明.txt
